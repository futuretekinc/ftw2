# IAR project postfetch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADK_IOT_COAP; APP_MDNS_ENABLE; ADK_PROV_WPS_ENABLE; ADK_FILE_UPLOAD_API; GSN_FILE_UPLOAD_API; ADK_OTAFU_ENABLE; TX_ENABLE_IAR_LIBRARY_SUPPORT; IAR; GSN_RUN_FROM_SRAM; RUN_ALL_FROM_RAM; TM_USE_HTTPD; ADK_PROV_ENABLE; NX_INCLUDE_USER_DEFINE_FILE; INLINE=static
  ICCARM.CCIncludePath2: ..\..\..\geps\inc; ..\..\..\geps\inc\core; ..\..\..\geps\inc\drivers; ..\..\..\geps\inc\modules; ..\..\..\geps\inc\modules\http; ..\..\..\geps\inc\rtos; ..\..\..\geps\inc\netx; ..\..\..\geps\inc\netx\netx_bsd_layer; ..\..\..\geps\inc\main; ..\..\..\geps\inc\fs; ..\..\..\geps\inc\fs\hcc\src; ..\..\..\geps\inc\security\src\; ..\..\..\geps\inc\security\hw_engine_if; ..\..\..\geps\inc\security\wpa_if; ..\..\..\userlib\ncm\inc; ..\..\..\userlib; ..\inc\ctx; ..\inc; ..\inc\main; ..\inc\parser; ..\inc\config; ..\src; ..\inc\tls; ..\inc\rtc_mem; ..\inc\sm; ..\inc\ncm; ..\inc\debug; ..\..\..\adk\otafu\inc; ..\..\..\adk\provisioning\inc; ..\..\..\system\gsn\inc; ..\..\..\system\gsn\inc\core; ..\..\..\system\gsn\inc\drivers; ..\..\..\system\gsn\inc\modules; ..\..\..\system\\rtos\tx; ..\..\..\system\nw; ..\..\..\system\nw\netx; ..\..\..\system\nw\netx\netx_bsd_layer; ..\..\..\system\main; ..\..\..\system\security\src\; ..\..\..\system\security\\inc\hw_engine_if; ..\..\..\system\security\src\wpa_supplicant-1.0\src; ..\..\..\system\fs\hcc\src; ..\..\..\system; ..\inc; ..\inc\ctx; ..\inc\main; ..\inc\fs_if; ..\inc\config; ..\inc\sm; ..\inc\ncm; ..\inc\debug; ..\inc\tls; ..\inc\rtc_mem; ..\..\..\userlib\ncm\inc; ..\..\..\adk\provisioning\inc; ..\..\..\adk\otafu\inc; ..\..\..\system\gsn\inc\modules\http; ..\..\..\adk\cloud_connect\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: postfetch.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/tls/: app_data_send.c
    ../src/fwup/: app_fwup.c
    ../src/net_svcs/: app_iot_gateway_updater.c app_mdns.c app_network_services.c
    ../src/main/: app_L2L3_init.c
    ../src/ncm/: app_ncm.c
    ../src/sm/: app_sm.c
    ../../../userlib/ncm/src/: gsn_ncm.c
