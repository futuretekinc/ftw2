# IAR project otafu.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: GSN_FILE_UPLOAD_API; TX_ENABLE_IAR_LIBRARY_SUPPORT; IAR; TM_USE_HTTPC; TM_USE_HTTPD; GSN_WEB_SERVER; GSN_GSLINK; GSN_GSLINK_XML; TM_USE_HTTPD_CGI; USE_V6; GSN_FILE_UPLOAD_API; S2W_WEB_PROV; ADK_PROV; ADK_OTAFU
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\system\gsn\inc; ..\..\..\system\gsn\inc\core; ..\..\..\system\gsn\inc\drivers; ..\..\..\system\gsn\inc\modules; ..\..\..\system\nw; ..\..\..\system\nw\netx; ..\..\..\system\nw\netx\netx_bsd_layer; ..\..\..\system\rtos\tx; ..\..\..\system\; ..\..\..\system\security\src\; ..\..\..\system\security\\inc\hw_engine_if; ..\..\..\system\security\src\wpa_supplicant-1.0\src; ..\..\..\system\fs\hcc\src\; ..\..\..\system\gsn\src\modules\http\include; ..\..\..\system\main; ..\..\otafu\inc; ..\..\..\geps\inc; ..\..\..\geps\inc\core; ..\..\..\geps\inc\drivers; ..\..\..\geps\inc\modules; ..\..\..\geps\inc\modules\nw; ..\..\..\geps\inc\modules\nw\netx; ..\..\..\geps\inc\modules\nw\netx\netx_bsd_layer; ..\..\..\geps\inc\rtos\tx; ..\..\..\geps\; ..\..\..\geps\inc\security\wpa_if; ..\..\..\geps\inc\security\hw_engine_if; ..\..\..\geps\inc\security\wpa_supp_patch; ..\..\..\geps\inc\supplicant; ..\..\..\geps\inc\fs; ..\..\..\geps\inc\modules\http\include; ..\..\..\geps\inc\main
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: otafu.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ../src/: gsn_dsv_httpd.c gsn_ext_otafu.c gsn_otafu.c gsn_otafu_dsv.c
