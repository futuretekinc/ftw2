# IAR project tls.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ADK_PROV_WPS_ENABLE; GSN_FILE_UPLOAD_API; ADK_FILE_UPLOAD_API; ADK_OTAFU_ENABLE; TX_ENABLE_IAR_LIBRARY_SUPPORT; IAR; TM_USE_HTTPD; GSN_GSLINK; GSN_WEB_SERVER; APP_MDNS; NX_INCLUDE_USER_DEFINE_FILE; NO_ADK_PROV_GROUP_SECURE
  ICCARM.CCDiagSuppress: Pa050, Go005
  ICCARM.CCIncludePath2: ..\..\..\geps\inc; ..\..\..\geps\inc\core; ..\..\..\geps\inc\drivers; ..\..\..\geps\inc\modules; ..\..\..\geps\inc\modules\http; ..\..\..\geps\inc\rtos; ..\..\..\geps\inc\netx; ..\..\..\geps\inc\netx\netx_bsd_layer; ..\..\..\geps\inc\main; ..\..\..\geps\inc\fs; ..\..\..\geps\inc\fs\hcc\src; ..\..\..\geps\inc\security\src\; ..\..\..\geps\inc\security\hw_engine_if; ..\..\..\geps\inc\security\wpa_if; ..\..\..\geps\inc\supplicant; ..\..\..\userlib\ncm\inc; ..\..\..\userlib; ..\..\..\system\gsn\inc; ..\..\..\system\gsn\inc\core; ..\..\..\system\gsn\inc\drivers; ..\..\..\system\gsn\inc\modules; ..\..\..\system\\rtos\tx; ..\..\..\system\nw; ..\..\..\system\nw\netx; ..\..\..\system\nw\netx\netx_bsd_layer; ..\..\..\system\main; ..\..\..\system\security\src\; ..\..\..\system\security\\inc\hw_engine_if; ..\..\..\system\security\src\wpa_supplicant-1.0\src; ..\..\..\system\fs\hcc\src; ..\..\..\system; ..\inc; ..\inc\ctx; ..\inc\main; ..\inc\fs_if; ..\inc\config; ..\inc\sm; ..\inc\ncm; ..\inc\debug; ..\inc\tls; ..\inc\rtc_mem; ..\inc\ext_app; ..\inc\wps; ..\..\..\adk\provisioning\inc; ..\..\..\adk\otafu\inc; ..\..\..\adk\cloud_connect\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app.bin
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkKeepSymbols: GsnStartup_Main
  ILINK.IlinkIcfFile: app_flashFetch.icf
  ILINK.IlinkExtraOptions: -f  ..\..\..\geps\lib\rom_patch_fpt_symbols.txt; --keep rom_patch_auto_dummy1; --keep rom_patch_auto_dummy2; --entry App_Main; --redirect malloc=MALLOC; --redirect free=FREE
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: s2w.srec
  ILINK.IlinkOutputFile: uart_test.out
  group (top)
    ../src/ext_app/: app_ext_flash.c
    ../src/main/: app_main.c app_main_thread.c app_startup.c
    ./: cstartup_M.s prefetch.a tx_initialize_low_level.s
    ../../../geps/lib/: gsn_modules_flash.a rom-final.a rom_patch_app.a rom_patch_auto.a rom_patch_fpt.a
    ../../otafu/lib/: otafu.a
    ../../provisioning/lib/: web_prov.a
