# IAR project prefetch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ADK_PROV_WPS_ENABLE; ADK_FILE_UPLOAD_API; GSN_FILE_UPLOAD_API; ADK_OTAFU_ENABLE; TX_ENABLE_IAR_LIBRARY_SUPPORT; IAR; GSN_RUN_FROM_SRAM; RUN_ALL_FROM_RAM; TM_USE_HTTPD; ADK_PROV_ENABLE; ADK_PROV; APP_MDNS_ENABLE; NX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCDiagSuppress: Pa050, Go005
  ICCARM.CCIncludePath2: ..\..\..\geps\inc; ..\..\..\geps\inc\core; ..\..\..\geps\inc\drivers; ..\..\..\geps\inc\modules; ..\..\..\geps\inc\modules\http; ..\..\..\geps\inc\rtos; ..\..\..\geps\inc\netx; ..\..\..\geps\inc\netx\netx_bsd_layer; ..\..\..\geps\inc\main; ..\..\..\geps\inc\fs; ..\..\..\geps\inc\fs\hcc\src; ..\..\..\geps\inc\security\src\; ..\..\..\geps\inc\security\hw_engine_if; ..\..\..\geps\inc\security\wpa_if; ..\..\..\userlib\ncm\inc; ..\..\..\userlib; ..\..\..\adk\otafu\inc; ..\..\..\adk\provisioning\inc; ..\..\..\system\gsn\inc; ..\..\..\system\gsn\inc\core; ..\..\..\system\gsn\inc\drivers; ..\..\..\system\gsn\inc\modules; ..\..\..\system\\rtos\tx; ..\..\..\system\nw; ..\..\..\system\nw\netx; ..\..\..\system\nw\netx\netx_bsd_layer; ..\..\..\system\main; ..\..\..\system\security\src\; ..\..\..\system\security\\inc\hw_engine_if; ..\..\..\system\security\src\wpa_supplicant-1.0\src; ..\..\..\system\fs\hcc\src; ..\..\..\system; ..\inc; ..\inc\ctx; ..\inc\main; ..\inc\fs_if; ..\inc\config; ..\inc\sm; ..\inc\ncm; ..\inc\debug; ..\inc\tls; ..\inc\rtc_mem; ..\src\net_svcs; ..\..\..\userlib\ncm\inc; ..\..\..\adk\provisioning\inc; ..\..\..\adk\otafu\inc; ..\..\..\system\gsn\inc\modules\http; ..\..\..\adk\cloud_connect\inc; ..\..\..\system\gsn\inc\modules\ssl
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: gsn.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration gsn_build_config (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: TX_ENABLE_IAR_LIBRARY_SUPPORT; _DLIB_FILE_DESCRIPTOR; IAR; GSN_SECURITY_ENTERPRISE_AVAILABLE; TM_USE_HTTPC; TM_USE_HTTPD; GSN_WEB_SERVER; GSN_GSLINK; GSN_GSLINK_XML; TM_USE_HTTPD_CGI; USE_V6; GSN_FILE_UPLOAD_API; GSN_NCM_AUTO_CHANNEL_SWITCH
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\inc\core; ..\..\inc\drivers; ..\..\inc\modules; ..\..\..\nw; ..\..\..\nw\netx; ..\..\..\nw\netx\netx_bsd_layer; ..\..\..\rtos\tx; ..\..\..\fs\hcc\src; ..\..\..\..\system\; ..\..\..\..\system\main; ..\..\..\..\system\security\src\; ..\..\..\..\system\security\\inc\hw_engine_if; ..\..\..\..\system\security\src\wpa_supplicant-1.0\src; ..\..\..\fs\hcc\src\; ..\..\..\src\modules\http\include; ..\..\..\..\adk\provisioning\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ../src/battery/: app_batt_chk.c
    ../src/config/: app_cfg.c
    ../src/net_svcs/: app_cloud_helper.c app_httpd.c app_httpd_cb.c app_iot_gateway_updater.c app_mdns.c app_network_services.c
    ../src/debug/: app_debug.c app_uart_print.c
    ../src/fs_if/: app_fsIf.c
    ../src/fwup/: app_fwup.c
    ../src/tls/: app_http_api.c app_tls.c
    ../src/ncm/: app_ncm.c
    ../src/rtc_mem/: app_rtc_mem.c
    ../src/sm/: app_sm.c
    ../src/wps/: app_wps.c
    ../../cloud_connect/src/: gsn_cloud_api.c gsn_cloud_exosite.c gsn_cloud_sp.c gsn_cloud_tls.c gsn_cloud_updater.c
    ../../../userlib/ncm/src/: gsn_ncm.c
