<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\s2w.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\s2w_emu.ewp</path>
  </project>
  <batchBuild/>
</workspace>


