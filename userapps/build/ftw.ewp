# IAR project ftw.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: TX_ENABLE_IAR_LIBRARY_SUPPORT; IAR; FIXED_ROM_BUILD; RUN_ALL_FROM_FLASH; TM_USE_HTTPD; FTW_DNS_CLIENT; NX_INCLUDE_USER_DEFINE_FILE; FTW_WEB_FS_AVAILABLE; FTW_EXTFLASH_DRIVER_TEST; FTW_PWM_SUPPORT; FTW_MEM_ACCESS; FTW_FORCE_UART_PORT; FTW_EXT_FLASH_FWUP_PUSH_METHOD; FTW_NCM_SUPPORT_ENABLE; FTW_SECURITY_ENTERPRISE_PEAP_V0_AVAILABLE; FTW_EXT_FLASH_FWUP_PULL_METHOD; FTW_SECURITY_ENTERPRISE_TLS_AVAILABLE; FTW_DNS_SERVER_ENABLE; ADK_OTAFU; FTW_GSLINK_RAW; FTW_GSLINK_XML; FTW_SECURITY_ENTERPRISE_PEAP_V1_AVAILABLE; FTW_PING_TRACE; FTW_RF_TEST; FTW_SSL_CLIENT_SUPPORT; FTW_DHCP_SERVER_ENABLE; FTW_SECURITY_WPS_ENABLE; ADK_PROV_CONFIG_LIMITED_AP; FTW_WEB_SERVER; ADK_PROV; FTW_FILE_UPLOAD_API; FTW_COAP_SUPPORT; FTW_HTTPD_SSLCERT_UPLOAD; FTW_FACT_IMAGE_REQ; FTW_ASYNC_MSG; FTW_HTTPS_SUPPORT; FTW_SECURITY_ENTERPRISE_FAST_GTC_AVAILABLE; FTW_WEB_PROV; FTW_UNASSOC_TXRX_SUPPORT; FTW_SNTP; FTW_UART_ENABLE; FTW_GSLINK_XMLNESTED_PARSER; FTW_GSLINK; FTW_SECURITY_ENTERPRISE_TTLS_AVAILABLE; FTW_ADC_SUPPORT; FTW_HTTPC_SUPPORT; FTW_SECURITY_ENTERPRISE_FAST_MSCHAPV2_AVAILABLE; FTW_SSL_SERVER_SUPPORT; ADK_PROV_CONFIG_CLIENT; FTW_MDNS_ENABLE
  ICCARM.CCDiagSuppress: Pa050, Pe231, Pe177
  ICCARM.CCIncludePath2: ..\..\geps\inc; ..\..\geps\inc\core; ..\..\geps\inc\drivers; ..\..\geps\inc\modules; ..\..\geps\inc\rtos; ..\..\geps\inc\netx; ..\..\geps\inc\netx\netx_bsd_layer; ..\..\geps\inc\main; ..\..\geps\inc\fs; ..\..\geps\inc\fs\hcc\src; ..\..\geps\inc\security\src\; ..\..\geps\inc\security\hw_engine_if; ..\..\geps\inc\security\wpa_if; ..\..\userlib\ncm\inc; ..\..\userlib; ..\inc\ctx; ..\inc; ..\inc\main; ..\inc\hal; ..\inc\parser; ..\inc\config; ..\inc\ftw; ..\src; ..\..\adk\otafu\inc; ..\..\adk\provisioning\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app.bin
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkIcfFile: app_flashFetch.icf
  ILINK.IlinkExtraOptions: -f ..\..\geps\lib\rom_patch_fpt_symbols.txt; --keep rom_patch_auto_dummy1; --keep rom_patch_auto_dummy2; --entry GsnStartup_Main; --redirect malloc=MALLOC; --redirect free=FREE
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: ftw.srec
  ILINK.IlinkOutputFile: uart_test.out
  group (top)
    ../src/clk_tune/: app_clk_tune.c
    ../src/emu/: app_emu.c
    ../src/ext_app/: app_ext_flash.c
    ../src/main/: app_main.c app_main_thread.c s2w_l2_dev.c
    ../src/gslink/: app_mcu_http_api.c
    ../src/rtc_mem/: app_rtc_mem.c
    ./: gsn_flash_startup.c
    ../src/parser/: s2w_154_command.c s2w_ext_flash_command.c s2w_general_command.c s2w_general_parse.c s2w_misc_command.c s2w_process.c s2w_zip_command.c
    ../src/hal/: s2w_ext_flash_fwup.c s2w_net_gainspan.c s2w_os_gainspan.c
    ../src/web_prov/: s2w_web_prov.c
  group ftw
    ../src/ftw/: ftw_battery.c ftw_cert.c ftw_config.c ftw_debug.c ftw_fs.c ftw_hal.c ftw_hal_general.c ftw_hal_httpd.c ftw_hal_net.c ftw_hal_rtc.c ftw_serial.c ftw_shell.c ftw_spi.c ftw_time.c ftw_uart.c
  group include
    ../inc/ftw/: ftw_cert.h ftw_config.h ftw_debug.h ftw_hal.h ftw_hal_net.h ftw_includes.h ftw_list.h ftw_mem.h ftw_mqtt.h ftw_mqtt_tp.h ftw_net.h ftw_serial.h ftw_time.h ftw_types.h ftw_uart.h libemqtt.h nxjson.h
  group libs
    ../../geps/lib/: gsn_modules_flash.a rom-final.a rom_patch_app.a rom_patch_auto.a rom_patch_fpt.a
    ../../adk/otafu/lib/: otafu.a
    ../../adk/provisioning/lib/: web_prov.a
  group mqtt
    ../src/mqtt/: ftw_list.c ftw_mqtt.c libemqtt.c
    ../src/ftw/: ftw_mqtt_tp.c
    ../src/nxjson/: nxjson.c
  group ncm
    ../../userlib/ncm/src/: gsn_ncm.c gsn_ncm_roam.c
  group net
    ../src/net/: ftw_net.c
