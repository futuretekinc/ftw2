<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ftw.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ftw_emu.ewp</path>
  </project>
  <batchBuild/>
</workspace>


